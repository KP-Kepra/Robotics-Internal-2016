# Keil uVision project ustrobo16_internal.uvprojx, settings and files
target stm32f103rb_template (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ustrobo16_internal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_ML
  c include: .\src\stm32f10x_std\inc;.\src\library;.\src\user
  asm include: .\src\stm32f10x_startup;.\src\stm32f10x_std;.\src\library;.\src\user
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group stm32f10x_startup
    ./src/stm32f10x_startup/: startup_stm32f10x_md.s
  group stm32f10x_std
    ./src/stm32f10x_std/src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group library
    ./src/library/: ticks.c ultrasonic.c leds.c button.c uart.c servo.c motor.c delay.c lcd_blue.c lcd_font.c adc.c linear_ccd.c gpio.c pneumatic.c savgol.c IR_sensors.c Moving.c
  group user
    ./src/user/: main.c
